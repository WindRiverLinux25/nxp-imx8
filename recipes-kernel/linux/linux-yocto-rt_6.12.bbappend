require linux-yocto-nxp-imx8.inc

KBRANCH:nxp-imx8  = "v6.12/standard/preempt-rt/nxp-sdk-6.12/nxp-soc"
